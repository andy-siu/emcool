#include <cstring>

#include "emcool/ble/crypto.hpp"
#include "emcool/log.hpp"

namespace emcool::ble {

namespace {

constexpr const char* kTag = "ble-crypto";

// RFC 4231 §4.3, test case 2.
constexpr std::uint8_t kHmacExpected[32] = {0x5b, 0xdc, 0xc1, 0x46, 0xbf, 0x60, 0x75, 0x4e, 0x6a, 0x04, 0x24,
                                            0x26, 0x08, 0x95, 0x75, 0xc7, 0x5a, 0x00, 0x3f, 0x08, 0x9d, 0x27,
                                            0x39, 0x83, 0x9d, 0xec, 0x58, 0xb9, 0x64, 0xec, 0x38, 0x43};
// GCM spec test case 16: a 256-bit key, 20 bytes of additional data and 60 of plaintext, so a
// partial last block. Not test case 13, whose plaintext is empty: ESP-IDF 6.1's GCM refuses an
// empty message ("No input supplied"), and the link never seals one (crypto.hpp).
constexpr std::uint8_t kGcmKey16[32] = {0xfe, 0xff, 0xe9, 0x92, 0x86, 0x65, 0x73, 0x1c, 0x6d, 0x6a, 0x8f,
                                        0x94, 0x67, 0x30, 0x83, 0x08, 0xfe, 0xff, 0xe9, 0x92, 0x86, 0x65,
                                        0x73, 0x1c, 0x6d, 0x6a, 0x8f, 0x94, 0x67, 0x30, 0x83, 0x08};
constexpr std::uint8_t kGcmIv16[12] = {0xca, 0xfe, 0xba, 0xbe, 0xfa, 0xce, 0xdb, 0xad, 0xde, 0xca, 0xf8, 0x88};
constexpr std::uint8_t kGcmAad16[20] = {0xfe, 0xed, 0xfa, 0xce, 0xde, 0xad, 0xbe, 0xef, 0xfe, 0xed,
                                        0xfa, 0xce, 0xde, 0xad, 0xbe, 0xef, 0xab, 0xad, 0xda, 0xd2};
constexpr std::uint8_t kGcmPlain16[60] = {
    0xd9, 0x31, 0x32, 0x25, 0xf8, 0x84, 0x06, 0xe5, 0xa5, 0x59, 0x09, 0xc5, 0xaf, 0xf5, 0x26,
    0x9a, 0x86, 0xa7, 0xa9, 0x53, 0x15, 0x34, 0xf7, 0xda, 0x2e, 0x4c, 0x30, 0x3d, 0x8a, 0x31,
    0x8a, 0x72, 0x1c, 0x3c, 0x0c, 0x95, 0x95, 0x68, 0x09, 0x53, 0x2f, 0xcf, 0x0e, 0x24, 0x49,
    0xa6, 0xb5, 0x25, 0xb1, 0x6a, 0xed, 0xf5, 0xaa, 0x0d, 0xe6, 0x57, 0xba, 0x63, 0x7b, 0x39};
// Ciphertext, then tag.
constexpr std::uint8_t kGcmSealed16[76] = {
    0x52, 0x2d, 0xc1, 0xf0, 0x99, 0x56, 0x7d, 0x07, 0xf4, 0x7f, 0x37, 0xa3, 0x2a, 0x84, 0x42, 0x7d,
    0x64, 0x3a, 0x8c, 0xdc, 0xbf, 0xe5, 0xc0, 0xc9, 0x75, 0x98, 0xa2, 0xbd, 0x25, 0x55, 0xd1, 0xaa,
    0x8c, 0xb0, 0x8e, 0x48, 0x59, 0x0d, 0xbb, 0x3d, 0xa7, 0xb0, 0x8b, 0x10, 0x56, 0x82, 0x88, 0x38,
    0xc5, 0xf6, 0x1e, 0x63, 0x93, 0xba, 0x7a, 0x0a, 0xbc, 0xc9, 0xf6, 0x62, 0x76, 0xfc, 0x6e, 0xce,
    0x0f, 0x4e, 0x17, 0x68, 0xcd, 0xdf, 0x88, 0x53, 0xbb, 0x2d, 0x55, 0x1b};
// Test case 14: the same with 16 zero bytes of plaintext — ciphertext, then tag.
constexpr std::uint8_t kGcmBlockSealed[32] = {0xce, 0xa7, 0x40, 0x3d, 0x4d, 0x60, 0x6b, 0x6e, 0x07, 0x4e, 0xc5,
                                              0xd3, 0xba, 0xf3, 0x9d, 0x18, 0xd0, 0xd1, 0xc8, 0xa7, 0x99, 0x99,
                                              0x6b, 0xf0, 0x26, 0x5b, 0x98, 0xb5, 0xd4, 0x8a, 0xb9, 0x19};

std::span<const std::uint8_t> bytesOf(const char* text) {
  return {reinterpret_cast<const std::uint8_t*>(text), std::strlen(text)};
}

}  // namespace

bool cryptoSelfTest() {
  Sha256Digest digest = {};
  if (!hmacSha256(bytesOf("Jefe"), {bytesOf("what do ya "), bytesOf("want for nothing?")}, digest) ||
      std::memcmp(digest.data(), kHmacExpected, sizeof kHmacExpected) != 0) {
    logError(kTag, "HMAC-SHA256 failed RFC 4231 test case 2");
    return false;
  }

  AesKey key16 = {};
  GcmIv iv16 = {};
  std::memcpy(key16.data(), kGcmKey16, sizeof kGcmKey16);
  std::memcpy(iv16.data(), kGcmIv16, sizeof kGcmIv16);
  std::uint8_t sealed16[sizeof kGcmSealed16] = {};
  if (!aesGcmSeal(key16, iv16, kGcmAad16, kGcmPlain16, sealed16) ||
      std::memcmp(sealed16, kGcmSealed16, sizeof kGcmSealed16) != 0) {
    logError(kTag, "AES-256-GCM failed GCM test case 16");
    return false;
  }
  std::uint8_t opened16[sizeof kGcmPlain16] = {};
  if (!aesGcmOpen(key16, iv16, kGcmAad16, kGcmSealed16, opened16) ||
      std::memcmp(opened16, kGcmPlain16, sizeof kGcmPlain16) != 0) {
    logError(kTag, "AES-256-GCM could not open GCM test case 16");
    return false;
  }

  const AesKey zeroKey = {};
  const GcmIv zeroIv = {};
  std::uint8_t sealed[32] = {};
  const std::uint8_t zeroBlock[16] = {};
  if (!aesGcmSeal(zeroKey, zeroIv, {}, zeroBlock, sealed) || std::memcmp(sealed, kGcmBlockSealed, 32) != 0) {
    logError(kTag, "AES-256-GCM failed GCM test case 14");
    return false;
  }
  std::uint8_t opened[16] = {0xff};
  if (!aesGcmOpen(zeroKey, zeroIv, {}, kGcmBlockSealed, opened) || std::memcmp(opened, zeroBlock, 16) != 0) {
    logError(kTag, "AES-256-GCM could not open GCM test case 14");
    return false;
  }
  std::uint8_t tampered[32];
  std::memcpy(tampered, kGcmBlockSealed, 32);
  tampered[31] ^= 0x01;
  if (aesGcmOpen(zeroKey, zeroIv, {}, tampered, opened)) {
    logError(kTag, "AES-256-GCM accepted a tampered tag");
    return false;
  }
  return true;
}

}  // namespace emcool::ble
